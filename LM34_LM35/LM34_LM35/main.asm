;
; LM34_LM35.asm
;
; Created: 9/27/2023 11:09:46 AM
; Author : Options
;


; Replace with your application code

.INCLUDE "m32def.inc"

.ORG 0x00
MAIN:
LDI R16,0xFF
OUT DDRC,R16
OUT DDRD,R16
CBI DDRA,PA0

LDI R16,0xC0
OUT ADMUX,R16
LDI R16,0x87
OUT ADCSRA,R16

LOOP:
SBI ADCSRA,ADSC
HERE:
SBIS ADCSRA,ADIF
RJMP HERE
IN R24,ADCL
IN R25,ADCH
SUBI R24,LOW(220)
SBCI R25,HIGH(220)
ASR R25
ROR R24
ASR R25
ROR R24

OUT PORTC,R24
OUT PORTD,R25

RJMP LOOP

